require linux-yocto-rpi.inc

