# Raspberry Pi BSP - 6.1 Kernel

require linux-yocto-rpi.inc

FILESEXTRAPATHS:prepend := "${THISDIR}/linux-yocto-6.1:"

