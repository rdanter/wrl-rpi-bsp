# Raspberry Pi BSP - 5.15 Kernel

require linux-yocto-rpi.inc

FILESEXTRAPATHS:prepend := "${THISDIR}/linux-yocto-5.15:"

