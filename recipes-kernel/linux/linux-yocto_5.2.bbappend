# Raspberry Pi BSP - 5.2 Kernel

require linux-yocto-rpi.inc

FILESEXTRAPATHS_prepend := "${THISDIR}/linux-yocto-5.2:"

SRC_URI += "file://0001-arm-partially-revert-702b94bff3c50542a6e4ab9a4f4cef0.patch"
SRC_URI += "file://0002-Revert-rtc-pcf8523-properly-handle-oscillator-stop-b.patch"
SRC_URI += "file://0003-smsx95xx-fix-crimes-against-truesize.patch"
SRC_URI += "file://0004-smsc95xx-Experimental-Enable-turbo_mode-and-packetsi.patch"
SRC_URI += "file://0005-Allow-mac-address-to-be-set-in-smsc95xx.patch"
SRC_URI += "file://0006-Protect-__release_resource-against-resources-without.patch"
SRC_URI += "file://0007-irq-bcm2836-Prevent-spurious-interrupts-and-trap-the.patch"
SRC_URI += "file://0008-irq-bcm2836-Avoid-Invalid-trigger-warning.patch"
SRC_URI += "file://0009-irqchip-bcm2835-Add-FIQ-support.patch"
SRC_URI += "file://0010-irqchip-irq-bcm2835-Add-2836-FIQ-support.patch"
SRC_URI += "file://0011-spi-spidev-Completely-disable-the-spidev-warning.patch"
SRC_URI += "file://0012-dmaengine-bcm2835-Load-driver-early-and-support-lega.patch"
SRC_URI += "file://0013-firmware-Updated-mailbox-header.patch"
SRC_URI += "file://0014-rtc-Add-SPI-alias-for-pcf2123-driver.patch"
SRC_URI += "file://0015-watchdog-bcm2835-Support-setting-reboot-partition.patch"
SRC_URI += "file://0016-reboot-Use-power-off-rather-than-busy-spinning-when-.patch"
SRC_URI += "file://0017-bcm-Make-RASPBERRYPI_POWER-depend-on-PM.patch"
SRC_URI += "file://0018-Register-the-clocks-early-during-the-boot-process-so.patch"
SRC_URI += "file://0019-bcm2835-rng-Avoid-initialising-if-already-enabled.patch"
SRC_URI += "file://0020-clk-bcm2835-Mark-used-PLLs-and-dividers-CRITICAL.patch"
SRC_URI += "file://0021-clk-bcm2835-Add-claim-clocks-property.patch"
SRC_URI += "file://0022-clk-bcm2835-Read-max-core-clock-from-firmware.patch"
SRC_URI += "file://0023-clk-bcm2835-Mark-GPIO-clocks-enabled-at-boot-as-crit.patch"
SRC_URI += "file://0024-sound-Demote-deferral-errors-to-INFO-level.patch"
SRC_URI += "file://0025-Update-vfpmodule.c.patch"
SRC_URI += "file://0026-i2c-bcm2835-Add-debug-support.patch"
SRC_URI += "file://0027-mm-Remove-the-PFN-busy-warning.patch"
SRC_URI += "file://0028-ASoC-Add-prompt-for-ICS43432-codec.patch"
SRC_URI += "file://0029-irqchip-irq-bcm2836-Remove-regmap-and-syscon-use.patch"
SRC_URI += "file://0030-lan78xx-Enable-LEDs-and-auto-negotiation.patch"
SRC_URI += "file://0031-amba_pl011-Don-t-use-DT-aliases-for-numbering.patch"
SRC_URI += "file://0032-amba_pl011-Round-input-clock-up.patch"
SRC_URI += "file://0033-amba_pl011-Insert-mb-for-correct-FIFO-handling.patch"
SRC_URI += "file://0034-amba_pl011-Add-cts-event-workaround-DT-property.patch"
SRC_URI += "file://0035-pinctrl-bcm2835-Set-base-to-0-give-expected-gpio-num.patch"
SRC_URI += "file://0036-Main-bcm2708-bcm2709-linux-port.patch"
SRC_URI += "file://0037-Add-dwc_otg-driver.patch"
SRC_URI += "file://0038-bcm2708-framebuffer-driver.patch"
SRC_URI += "file://0039-fbdev-add-FBIOCOPYAREA-ioctl.patch"
SRC_URI += "file://0040-Speed-up-console-framebuffer-imageblit-function.patch"
SRC_URI += "file://0041-dmaengine-Add-support-for-BCM2708.patch"
SRC_URI += "file://0042-MMC-added-alternative-MMC-driver.patch"
SRC_URI += "file://0043-Adding-bcm2835-sdhost-driver-and-an-overlay-to-enabl.patch"
SRC_URI += "file://0044-vc_mem-Add-vc_mem-driver-for-querying-firmware-memor.patch"
SRC_URI += "file://0045-vcsm-VideoCore-shared-memory-service-for-BCM2835.patch"
SRC_URI += "file://0046-Add-dev-gpiomem-device-for-rootless-user-GPIO-access.patch"
SRC_URI += "file://0047-Add-SMI-driver.patch"
SRC_URI += "file://0048-MISC-bcm2835-smi-use-clock-manager-and-fix-reload-is.patch"
SRC_URI += "file://0049-Add-SMI-NAND-driver.patch"
SRC_URI += "file://0050-Revert-Add-SMI-NAND-driver.patch"
SRC_URI += "file://0051-Add-cpufreq-driver.patch"
SRC_URI += "file://0052-Add-Chris-Boot-s-i2c-driver.patch"
SRC_URI += "file://0053-char-broadcom-Add-vcio-module.patch"
SRC_URI += "file://0054-firmware-bcm2835-Support-ARCH_BCM270x.patch"
SRC_URI += "file://0055-scripts-Add-mkknlimg-and-knlinfo-scripts-from-tools-.patch"
SRC_URI += "file://0056-BCM2708-Add-core-Device-Tree-support.patch"
SRC_URI += "file://0057-BCM270x_DT-Add-pwr_led-and-the-required-input-trigge.patch"
SRC_URI += "file://0058-Added-Device-IDs-for-August-DVB-T-205.patch"
SRC_URI += "file://0059-Improve-__copy_to_user-and-__copy_from_user-performa.patch"
SRC_URI += "file://0060-gpio-poweroff-Allow-it-to-work-on-Raspberry-Pi.patch"
SRC_URI += "file://0061-mfd-Add-Raspberry-Pi-Sense-HAT-core-driver.patch"
SRC_URI += "file://0062-ASoC-Add-support-for-Rpi-DAC.patch"
SRC_URI += "file://0063-Add-IQaudIO-Sound-Card-support-for-Raspberry-Pi.patch"
SRC_URI += "file://0064-Added-support-for-HiFiBerry-DAC.patch"
SRC_URI += "file://0065-Added-driver-for-HiFiBerry-Amp-amplifier-add-on-boar.patch"
SRC_URI += "file://0066-Add-driver-for-rpi-proto.patch"
SRC_URI += "file://0067-Add-Support-for-JustBoom-Audio-boards.patch"
SRC_URI += "file://0068-New-AudioInjector.net-Pi-soundcard-with-low-jitter-a.patch"
SRC_URI += "file://0069-New-driver-for-RRA-DigiDAC1-soundcard-using-WM8741-W.patch"
SRC_URI += "file://0070-Add-support-for-Dion-Audio-LOCO-DAC-AMP-HAT.patch"
SRC_URI += "file://0071-Allo-Piano-DAC-boards-Initial-2-channel-stereo-suppo.patch"
SRC_URI += "file://0072-Add-support-for-Allo-Piano-DAC-2.1-plus-add-on-board.patch"
SRC_URI += "file://0073-Add-support-for-Allo-Boss-DAC-add-on-board-for-Raspb.patch"
SRC_URI += "file://0074-Support-for-Blokas-Labs-pisound-board.patch"
SRC_URI += "file://0075-ASoC-Add-driver-for-Cirrus-Logic-Audio-Card.patch"
SRC_URI += "file://0076-sound-Support-for-Dion-Audio-LOCO-V2-DAC-AMP-HAT.patch"
SRC_URI += "file://0077-Add-support-for-Fe-Pi-audio-sound-card.-1867.patch"
SRC_URI += "file://0078-Add-support-for-the-AudioInjector.net-Octo-sound-car.patch"
SRC_URI += "file://0079-Driver-support-for-Google-voiceHAT-soundcard.patch"
SRC_URI += "file://0080-Driver-and-overlay-for-Allo-Katana-DAC.patch"
SRC_URI += "file://0081-ASoC-Add-generic-RPI-driver-for-simple-soundcards.patch"
SRC_URI += "file://0082-ASoC-Add-Kconfig-and-Makefile-for-sound-soc-bcm.patch"
SRC_URI += "file://0083-ASoC-Create-a-generic-Pi-Hat-WM8804-driver.patch"
SRC_URI += "file://0084-rpi_display-add-backlight-driver-and-overlay.patch"
SRC_URI += "file://0085-bcm2835-virtgpio-Virtual-GPIO-driver.patch"
SRC_URI += "file://0086-net-Add-non-mainline-source-for-rtl8192cu-wlan.patch"
SRC_URI += "file://0087-OF-DT-Overlay-configfs-interface.patch"
SRC_URI += "file://0088-brcm-adds-support-for-BCM43341-wifi.patch"
SRC_URI += "file://0089-hci_h5-Don-t-send-conf_req-when-ACTIVE.patch"
SRC_URI += "file://0090-config-Add-default-configs.patch"
SRC_URI += "file://0091-Add-arm64-configuration-and-device-tree-differences..patch"
SRC_URI += "file://0092-ARM64-DWC_OTG-Port-dwc_otg-driver-to-ARM64.patch"
SRC_URI += "file://0093-ARM64-Round-Robin-dispatch-IRQs-between-CPUs.patch"
SRC_URI += "file://0094-ARM64-Force-hardware-emulation-of-deprecated-instruc.patch"
SRC_URI += "file://0095-build-arm64-Add-rules-for-.dtbo-files-for-dts-overla.patch"
SRC_URI += "file://0096-Revert-build-arm64-Add-rules-for-.dtbo-files-for-dts.patch"
SRC_URI += "file://0097-cache-export-clean-and-invalidate.patch"
SRC_URI += "file://0098-AXI-performance-monitor-driver-2222.patch"
SRC_URI += "file://0099-mcp2515-Use-DT-supplied-interrupt-flags.patch"
SRC_URI += "file://0100-cgroup-Disable-cgroup-memory-by-default.patch"
SRC_URI += "file://0101-ARM-bcm2835-Set-Serial-number-and-Revision.patch"
SRC_URI += "file://0102-dwc-otg-FIQ-Fix-bad-mode-in-data-abort-handler.patch"
SRC_URI += "file://0103-ARM-Activate-FIQs-to-avoid-__irq_startup-warnings.patch"
SRC_URI += "file://0104-serial-8250-bcm2835aux-suppress-EPROBE_DEFER.patch"
SRC_URI += "file://0105-raspberrypi-firmware-Export-the-general-transaction-.patch"
SRC_URI += "file://0106-drm-vc4-Add-a-mode-for-using-the-closed-firmware-for.patch"
SRC_URI += "file://0107-drm-vc4-Name-the-primary-and-cursor-planes-in-fkms.patch"
SRC_URI += "file://0108-drm-vc4-Add-DRM_DEBUG_ATOMIC-for-the-insides-of-fkms.patch"
SRC_URI += "file://0109-drm-vc4-Fix-sending-of-page-flip-completion-events-i.patch"
SRC_URI += "file://0110-drm-vc4-Add-support-for-setting-DPMS-in-firmwarekms.patch"
SRC_URI += "file://0111-drm-vc4-Add-FB-modifier-support-to-firmwarekms.patch"
SRC_URI += "file://0112-drm-vc4-Add-missing-enable-disable-vblank-handlers-i.patch"
SRC_URI += "file://0113-vc4_fkms-Apply-firmware-overscan-offset-to-hardware-.patch"
SRC_URI += "file://0114-drm-vc4-Fix-warning-about-vblank-interrupts-before-D.patch"
SRC_URI += "file://0115-drm-vc4-Skip-SET_CURSOR_INFO-when-the-cursor-content.patch"
SRC_URI += "file://0116-drm-vc4-Remove-duplicate-primary-cursor-fields-from-.patch"
SRC_URI += "file://0117-vc4_firmware_kms-fix-build.patch"
SRC_URI += "file://0118-gpu-vc4-fkms-Update-driver-to-not-use-plane-crtc.patch"
SRC_URI += "file://0119-drm-vc4-Don-t-wait-for-vblank-on-fkms-cursor-updates.patch"
SRC_URI += "file://0120-i2c-gpio-Also-set-bus-numbers-from-reg-property.patch"
SRC_URI += "file://0121-added-capture_clear-option-to-pps-gpio-via-dtoverlay.patch"
SRC_URI += "file://0122-lan78xx-Read-initial-EEE-status-from-DT.patch"
SRC_URI += "file://0123-hid-Reduce-default-mouse-polling-interval-to-60Hz.patch"
SRC_URI += "file://0124-Add-ability-to-export-gpio-used-by-gpio-poweroff.patch"
SRC_URI += "file://0125-firmware-raspberrypi-Notify-firmware-of-a-reboot.patch"
SRC_URI += "file://0126-irqchip-irq-bcm2835-Calc.-FIQ_START-at-boot-time.patch"
SRC_URI += "file://0127-of-configfs-Use-of_overlay_fdt_apply-API-call.patch"
SRC_URI += "file://0128-net-lan78xx-Disable-TCP-Segmentation-Offload-TSO.patch"
SRC_URI += "file://0129-brcmfmac-Re-enable-firmware-roaming-support.patch"
SRC_URI += "file://0130-lan78xx-Move-enabling-of-EEE-into-PHY-init-code.patch"
SRC_URI += "file://0131-Add-rpi-poe-fan-driver.patch"
SRC_URI += "file://0132-cxd2880-CXD2880_SPI_DRV-should-select-DVB_CXD2880-wi.patch"
SRC_URI += "file://0133-vchiq_2835_arm-Implement-a-DMA-pool-for-small-bulk-t.patch"
SRC_URI += "file://0134-hwmon-raspberrypi-Prevent-voltage-low-warnings-from-.patch"
SRC_URI += "file://0135-firmware-raspberrypi-Add-backward-compatible-get_thr.patch"
SRC_URI += "file://0136-sc16is7xx-Don-t-spin-if-no-data-received.patch"
SRC_URI += "file://0137-drivers-thermal-step_wise-add-support-for-hysteresis.patch"
SRC_URI += "file://0138-drivers-thermal-step_wise-avoid-throttling-at-hyster.patch"
SRC_URI += "file://0139-Update-issue-templates-2736.patch"
SRC_URI += "file://0140-gpiolib-Don-t-prevent-IRQ-usage-of-output-GPIOs.patch"
# Not needed since RCPL 3
#SRC_URI += "file://0141-lan78xx-disable-interrupts-for-PHY-irqs.patch"
SRC_URI += "file://0142-rpi-wm8804-soundcard-drop-PWRDN-register-writes.patch"
SRC_URI += "file://0143-rpi-wm8804-soundcard-configure-wm8804-clocks-only-on.patch"
SRC_URI += "file://0144-net-lan78xx-Support-auto-downshift-to-100Mb-s.patch"
SRC_URI += "file://0145-staging-bcm2835-camera-Ensure-H264-header-bytes-get-.patch"
SRC_URI += "file://0146-staging-bcm2835-camera-Check-the-error-for-REPEAT_SE.patch"
SRC_URI += "file://0147-firmware-raspberrypi-Report-the-fw-variant-during-pr.patch"
SRC_URI += "file://0148-firmware-raspberrypi-Report-the-fw-git-hash-during-p.patch"
SRC_URI += "file://0149-arm64-dts-broadcom-Enable-fixups-for-overlays.patch"
SRC_URI += "file://0150-bcm2835_smi-re-add-dereference-to-fix-DMA-transfers.patch"
SRC_URI += "file://0151-lan78xx-Debounce-link-events-to-minimize-poll-storm.patch"
SRC_URI += "file://0152-ASoC-Add-support-for-AudioSense-Pi-add-on-soundcard.patch"
SRC_URI += "file://0153-spi-spi-bcm2835-Re-enable-HW-CS.patch"
SRC_URI += "file://0154-spi-spi-bcm2835-Disable-forced-software-CS.patch"
SRC_URI += "file://0155-Added-driver-for-the-HiFiBerry-DAC-ADC-2694.patch"
SRC_URI += "file://0156-mfd-Add-rpi_sense_core-of-compatible-string.patch"
SRC_URI += "file://0157-configs-Enable-the-AD193x-codecs.patch"
SRC_URI += "file://0158-lan78xx-EEE-support-is-now-a-PHY-property.patch"
SRC_URI += "file://0159-Revert-staging-vchiq-delete-vchiq_killable.h.patch"
SRC_URI += "file://0160-Revert-staging-bcm2835-audio-Drop-DT-dependency.patch"
SRC_URI += "file://0161-gpu-vc4_firmware_kms-Fix-up-64-bit-compile-warnings.patch"
SRC_URI += "file://0162-bcm2835-dma-Add-support-for-per-channel-flags.patch"
SRC_URI += "file://0163-drm-vc4-Programming-the-CTM-is-conditional-on-runnin.patch"
SRC_URI += "file://0164-rtc-rv3028-Add-backup-switchover-mode-support.patch"
SRC_URI += "file://0165-Audiophonics-I-Sabre-9038Q2M-DAC-driver.patch"
SRC_URI += "file://0166-dt-bindings-rv3028-backup-switchover-support.patch"
SRC_URI += "file://0167-sound-Fixes-for-audioinjector-octo-under-4.19.patch"
SRC_URI += "file://0168-overlays-Add-PiGlow-overlay.patch"
SRC_URI += "file://0169-configs-enable-LED-driver-for-PiGlow.patch"
SRC_URI += "file://0170-dts-Increase-default-coherent-pool-size.patch"
SRC_URI += "file://0171-configs-Enable-netdev-LED-trigger.patch"
SRC_URI += "file://0172-lan78xx-use-default-alignment-for-rx-buffers.patch"
SRC_URI += "file://0173-BCM270X_DT-Also-set-coherent_pool-1M-for-BT-Pis.patch"
SRC_URI += "file://0174-configs-Enable-ICS-43432-I2S-microphone-module.patch"
SRC_URI += "file://0175-arm-dts-overlays-rpi-sense-add-upstream-humidity-com.patch"
SRC_URI += "file://0176-Added-IQaudIO-Pi-Codec-board-support-2969.patch"
SRC_URI += "file://0177-sound-pcm512x-codec-Adding-352.8kHz-samplerate-suppo.patch"
SRC_URI += "file://0178-allo-boss-dac-switch-to-snd_soc_dai_set_bclk_ratio.patch"
SRC_URI += "file://0179-hifiberry_dacplus-switch-to-snd_soc_dai_set_bclk_rat.patch"
SRC_URI += "file://0180-hifiberry_dacplusadc-switch-to-snd_soc_dai_set_bclk_.patch"
SRC_URI += "file://0181-media-ov5647-Add-set_fmt-and-get_fmt-calls.patch"
SRC_URI += "file://0182-media-Documentation-DT-add-device-tree-for-PWDN-cont.patch"
SRC_URI += "file://0183-media-ov5647-Add-support-for-PWDN-GPIO.patch"
SRC_URI += "file://0184-media-ov5647-Add-support-for-non-continuous-clock-mo.patch"
SRC_URI += "file://0185-media-tc358743-Increase-FIFO-level-to-374.patch"
SRC_URI += "file://0186-media-tc358743-fix-connected-active-CSI-2-lane-repor.patch"
SRC_URI += "file://0187-media-tc358743-Add-support-for-972Mbit-s-link-freq.patch"
SRC_URI += "file://0188-media-tc358743-Check-I2C-succeeded-during-probe.patch"
SRC_URI += "file://0189-media-adv7180-Default-to-the-first-valid-input.patch"
SRC_URI += "file://0190-media-adv7180-Add-YPrPb-support-for-ADV7282M.patch"
SRC_URI += "file://0191-media-videodev2-Add-helper-defines-for-printing-FOUR.patch"
SRC_URI += "file://0192-dt-bindings-Document-BCM283x-CSI2-CCP2-receiver.patch"
SRC_URI += "file://0193-media-bcm2835-unicam-Driver-for-CCP2-CSI2-camera-int.patch"
SRC_URI += "file://0194-MAINTAINERS-Add-entry-for-BCM2835-Unicam-driver.patch"
SRC_URI += "file://0195-defconfig-Enable-Unicam-driver-and-various-sources-o.patch"
SRC_URI += "file://0196-BCM283x-DT-Add-CSI-nodes-to-the-device-tree.patch"
SRC_URI += "file://0197-BCM270X_DT-Add-CSI-defines-for-all-the-downstream-Pi.patch"
SRC_URI += "file://0198-arm-dt-Add-DT-overlays-for-ADV7282M-OV5647-and-TC358.patch"
SRC_URI += "file://0199-dtoverlays-Add-support-for-ADV7280-M-ADV7281-M-and-A.patch"
SRC_URI += "file://0200-overlays-Remove-superfluous-address-size-cells.patch"
SRC_URI += "file://0201-dtoverlays-Add-i2c-on-0-1-option-to-TC358743-ADV7282.patch"
SRC_URI += "file://0202-media-bcm2835-unicam-Pass-through-the-colorspace-on-.patch"
SRC_URI += "file://0203-media-tc358743-Return-an-appropriate-colorspace-from.patch"
SRC_URI += "file://0204-staging-vchiq_arm-Fix-platform-device-unregistration.patch"
SRC_URI += "file://0205-staging-bcm2835-camera-Do-not-bulk-receive-from-serv.patch"
SRC_URI += "file://0206-staging-bcm2835-camera-Correctly-denote-key-frames-i.patch"
SRC_URI += "file://0207-staging-bcm2835-camera-Return-early-on-errors.patch"
SRC_URI += "file://0208-staging-bcm2835-camera-Remove-dead-email-addresses.patch"
SRC_URI += "file://0209-staging-bcm2835-camera-Fix-comment-style-violations.patch"
SRC_URI += "file://0210-staging-bcm2835-camera-Fix-spacing-around-operators.patch"
SRC_URI += "file://0211-staging-bcm2835-camera-Reduce-length-of-enum-names.patch"
SRC_URI += "file://0212-staging-bcm2835-camera-Fix-multiple-line-dereference.patch"
SRC_URI += "file://0213-staging-bcm2835-camera-Fix-brace-style-issues.patch"
SRC_URI += "file://0214-staging-bcm2835-camera-Fix-missing-lines-between-ite.patch"
SRC_URI += "file://0215-staging-bcm2835-camera-Fix-logical-continuation-spli.patch"
SRC_URI += "file://0216-staging-bcm2835-camera-Fix-open-parenthesis-alignmen.patch"
SRC_URI += "file://0217-staging-bcm2835-camera-Set-sequence-number-correctly.patch"
SRC_URI += "file://0218-staging-bcm2835-camera-Ensure-timestamps-never-go-ba.patch"
SRC_URI += "file://0219-staging-bcm2835-camera-Add-multiple-inclusion-protec.patch"
SRC_URI += "file://0220-staging-bcm2835-camera-Unify-header-inclusion-define.patch"
SRC_URI += "file://0221-staging-bcm2835-camera-Fix-multiple-assignments-shou.patch"
SRC_URI += "file://0222-staging-bcm2835-camera-Fix-up-all-formatting-in-mmal.patch"
SRC_URI += "file://0223-staging-bcm2835-camera-Use-enums-for-max-value-in-co.patch"
SRC_URI += "file://0224-staging-bcm2835-camera-Correct-V4L2_CID_COLORFX_CBCR.patch"
SRC_URI += "file://0225-staging-bcm2835-camera-Remove-amend-some-obsolete-co.patch"
SRC_URI += "file://0226-staging-vc04_services-Split-vchiq-mmal-into-a-module.patch"
SRC_URI += "file://0227-staging-mmal-vchiq-Allocate-and-free-components-as-r.patch"
SRC_URI += "file://0228-staging-mmal-vchiq-Avoid-use-of-bool-in-structures.patch"
SRC_URI += "file://0229-staging-mmal-vchiq-Make-timeout-a-defined-parameter.patch"
SRC_URI += "file://0230-staging-mmal-vchiq-Make-a-mmal_buf-struct-for-passin.patch"
SRC_URI += "file://0231-staging-mmal-vchiq-Add-support-for-event-callbacks.patch"
SRC_URI += "file://0232-staging-vc04_services-Support-sending-data-to-MMAL-p.patch"
SRC_URI += "file://0233-staging-vc04_services-Fixup-vchiq-mmal-include-order.patch"
SRC_URI += "file://0234-staging-vc04_services-Add-new-vc-sm-cma-driver.patch"
SRC_URI += "file://0235-staging-vc04_services-Use-vc-sm-cma-to-support-zero-.patch"
SRC_URI += "file://0236-media-videobuf2-Allow-exporting-of-a-struct-dmabuf.patch"
SRC_URI += "file://0237-staging-vc04_services-Add-a-V4L2-M2M-codec-driver.patch"
SRC_URI += "file://0238-config-Add-bcm2835-codec-to-Pi-defconfigs.patch"
SRC_URI += "file://0239-staging-bcm2835-camera-Fix-stride-on-RGB3-BGR3-forma.patch"
SRC_URI += "file://0240-char-vcio-Add-compat-ioctl-handling.patch"
SRC_URI += "file://0241-char-vcio-Fail-probe-if-rpi_firmware-is-not-found.patch"
SRC_URI += "file://0242-staging-mmal-vchiq-Fix-client_component-for-64-bit-k.patch"
SRC_URI += "file://0243-staging-bcm2835-camera-Add-sanity-checks-for-queue_s.patch"
SRC_URI += "file://0244-staging-bcm2835-camera-Set-the-field-value-within-ea.patch"
SRC_URI += "file://0245-char-vc_mem-Fix-up-compat-ioctls-for-64bit-kernel.patch"
SRC_URI += "file://0246-char-vc_mem-Fix-all-coding-style-issues.patch"
SRC_URI += "file://0247-clk-clk-bcm2835-Use-zd-when-printing-size_t.patch"
SRC_URI += "file://0248-dtoverlays-Correct-DT-handling-camera-GPIOs.patch"
SRC_URI += "file://0249-media-ov5647-Use-gpiod_set_value_cansleep.patch"
SRC_URI += "file://0250-media-bcm2835-unicam-Power-on-subdev-on-open-release.patch"
SRC_URI += "file://0251-staging-bcm2835-camera-Correct-ctrl-min-max-step-def.patch"
SRC_URI += "file://0252-staging-bcm2835-codec-variable-vb2-may-be-used-unini.patch"
SRC_URI += "file://0253-staging-bcm2835-codec-Fix-potentially-uninitialised-.patch"
SRC_URI += "file://0254-staging-vc-sm-cma-Correct-DMA-configuration.patch"
SRC_URI += "file://0255-staging-vc-sm-cma-Use-a-void-pointer-as-the-handle-w.patch"
SRC_URI += "file://0256-staging-vc-sm-cma-Fix-up-for-64bit-builds.patch"
SRC_URI += "file://0257-staging-mmal_vchiq-Add-in-the-Bayer-encoding-formats.patch"
SRC_URI += "file://0258-staging-mmal-vchiq-Always-return-the-param-size-from.patch"
SRC_URI += "file://0259-staging-mmal-vchiq-If-the-VPU-returns-an-error-don-t.patch"
SRC_URI += "file://0260-staging-bcm2835_codec-Query-supported-formats-from-t.patch"
SRC_URI += "file://0261-staging-bcm2835_codec-Add-support-for-the-ISP-as-an-.patch"
SRC_URI += "file://0262-staging-bcm2835_codec-Add-an-option-for-ignoring-Bay.patch"
SRC_URI += "file://0263-staging-bcm2835_codec-Fix-handling-of-VB2_MEMORY_DMA.patch"
SRC_URI += "file://0264-staging-mmal-vchiq-Update-mmal_parameters.h-with-rec.patch"
SRC_URI += "file://0265-staging-bcm2835_codec-Include-timing-info-in-SPS-hea.patch"
SRC_URI += "file://0266-staging-vc_sm_cma-Remove-erroneous-misc_deregister.patch"
SRC_URI += "file://0267-staging-bcm2835-codec-NULL-component-handle-on-queue.patch"
SRC_URI += "file://0268-staging-vc-sm-cma-Remove-the-debugfs-directory-on-re.patch"
SRC_URI += "file://0269-staging-vc-sm-cma-Use-devm_-allocs-for-sm_state.patch"
SRC_URI += "file://0270-staging-vc-sm-cma-Don-t-fail-if-debugfs-calls-fail.patch"
SRC_URI += "file://0271-staging-vc-sm-cma-Ensure-mutex-and-idr-are-destroyed.patch"
SRC_URI += "file://0272-staging-bcm2835_codec-Clean-up-logging-on-unloading-.patch"
SRC_URI += "file://0273-media-bcm2835-unicam-Add-support-for-enum-framesizes.patch"
SRC_URI += "file://0274-staging-bcm2835-codec-Refactor-default-resolution-co.patch"
SRC_URI += "file://0275-staging-bcm2835-codec-Correct-port-width-calc-for-tr.patch"
SRC_URI += "file://0276-staging-bcm2835-codec-Remove-height-padding-for-ISP-.patch"
SRC_URI += "file://0277-staging-mmal-vchiq-Free-the-event-context-for-contro.patch"
SRC_URI += "file://0278-staging-mmal-vchiq-Fix-memory-leak-in-error-path.patch"
SRC_URI += "file://0279-overlays-Update-upstream-overlay.patch"
SRC_URI += "file://0280-Bluetooth-Check-key-sizes-only-when-Secure-Simple-Pa.patch"
SRC_URI += "file://0281-usb-dwc_otg-Clean-up-interrupt-claiming-code.patch"
SRC_URI += "file://0282-overlays-Delete-the-deprecated-sdio-1bit-overlay.patch"
SRC_URI += "file://0283-overlays-Remove-upstream-aux-interrupt-overlay.patch"
SRC_URI += "file://0284-overlays-Standardise-on-compatible-brcm-bcm2835.patch"
SRC_URI += "file://0285-vc4-Remove-interrupt-and-DMA-trampling.patch"
SRC_URI += "file://0286-BCM270X_DT-Add-non-removable-clone-of-mmc-node.patch"
SRC_URI += "file://0287-BCM270X_DT-usb-Refactor-DTS-and-overlays.patch"
SRC_URI += "file://0288-BCM270X_DT-Rename-Pi-Zero-W-DT-files.patch"
SRC_URI += "file://0289-BCM270X_DT-Create-bcm2708-rpi-zero.dts.patch"
SRC_URI += "file://0290-overlays-Fix-mmc-related-overlays-after-refactor.patch"
SRC_URI += "file://0291-config-Add-NF_TABLES-support.patch"
SRC_URI += "file://0292-Fixed-48k-timing-issue.patch"
SRC_URI += "file://0293-staging-bcm2835-codec-Convert-V4L2-nsec-timestamps-t.patch"
SRC_URI += "file://0294-staging-bcm2835-codec-Add-support-for-setting-S_PARM.patch"
SRC_URI += "file://0295-w1-w1-gpio-Make-GPIO-an-output-for-strong-pullup.patch"
SRC_URI += "file://0296-overlays-Update-w1-gpio-and-w1-gpio-pullup.patch"
SRC_URI += "file://0297-bcm2835-sdhost-Fix-DMA-channel-leak-on-error-remove.patch"
SRC_URI += "file://0298-i2c-bcm2835-Model-Divider-in-CCF.patch"
SRC_URI += "file://0299-tty-amba-pl011-allow-shared-interrupt.patch"
SRC_URI += "file://0300-ARM-bcm283x-Reduce-register-ranges-for-UART-SPI-and-.patch"
SRC_URI += "file://0301-ARM-dts-Add-label-to-bcm2835-RNG.patch"
SRC_URI += "file://0302-dts-Use-fb-rather-than-leds-for-dpi-overlay.patch"
SRC_URI += "file://0303-BCM270X_DT-Minor-tidy-up.patch"
SRC_URI += "file://0304-arm-bcm2835-Fix-FIQ-early-ioremap.patch"
SRC_URI += "file://0305-Fix-copy_from_user-if-BCM2835_FAST_MEMCPY-n.patch"
SRC_URI += "file://0306-PCI-brcmstb-Add-Broadcom-STB-PCIe-host-controller-dr.patch"
SRC_URI += "file://0307-PCI-brcmstb-Add-dma-range-mapping-for-inbound-traffi.patch"
SRC_URI += "file://0308-PCI-brcmstb-Add-MSI-capability.patch"
SRC_URI += "file://0309-dt-bindings-pci-Add-DT-docs-for-Brcmstb-PCIe-device.patch"
SRC_URI += "file://0310-pcie-brcmstb-Changes-for-BCM2711.patch"
SRC_URI += "file://0311-arm-bcm2835-DMA-can-only-address-1GB.patch"
SRC_URI += "file://0312-mmc-bcm2835-sdhost-Support-64-bit-physical-addresses.patch"
SRC_URI += "file://0313-mmc-sdhci-Mask-spurious-interrupts.patch"
SRC_URI += "file://0314-mmc-sdhci-iproc-Add-support-for-emmc2-of-the-BCM2838.patch"
SRC_URI += "file://0315-hwrng-iproc-rng200-Add-BCM2838-support.patch"
SRC_URI += "file://0316-thermal-brcmstb_thermal-Add-BCM2838-support.patch"
SRC_URI += "file://0317-vchiq-Add-36-bit-address-support.patch"
SRC_URI += "file://0318-bcm2835-pcm.c-Support-multichannel-audio.patch"
SRC_URI += "file://0319-bcmgenet-constrain-max-DMA-burst-length.patch"
SRC_URI += "file://0320-bcmgenet-Better-coalescing-parameter-defaults.patch"
# Patch rework needed since at least RCPL 2
#SRC_URI += "file://0321-net-genet-enable-link-energy-detect-powerdown-for-ex.patch"
SRC_URI += "file://0001-net-genet-enable-link-energy-detect-powerdown-for-ex.patch"
SRC_URI += "file://0322-phy-broadcom-split-out-the-BCM54213PE-from-the-BCM54.patch"
SRC_URI += "file://0323-phy-bcm54213pe-configure-the-LED-outputs-to-be-more-.patch"
SRC_URI += "file://0324-dwc_otg-Choose-appropriate-IRQ-handover-strategy.patch"
SRC_URI += "file://0325-usb-xhci-Disable-the-XHCI-5-second-timeout.patch"
SRC_URI += "file://0326-usb-xhci-Show-that-the-VIA-VL805-supports-LPM.patch"
SRC_URI += "file://0327-pinctrl-bcm2835-Add-support-for-BCM2838.patch"
SRC_URI += "file://0328-spi-bcm2835-enable-shared-interrupt-support.patch"
SRC_URI += "file://0329-drivers-char-add-chardev-for-mmap-ing-Argon-control-.patch"
SRC_URI += "file://0330-clk-bcm2835-Don-t-wait-for-pllh-lock.patch"
SRC_URI += "file://0331-soc-bcm-bcm2835-pm-Add-support-for-2711.patch"
SRC_URI += "file://0332-staging-vc-sm-cma-Remove-obsolete-comment-and-make-f.patch"
SRC_URI += "file://0333-staging-vc-sm-cma-Add-in-allocation-for-VPU-requests.patch"
SRC_URI += "file://0334-staging-vc-sm-cma-Update-TODO.patch"
SRC_URI += "file://0335-staging-vc-sm-cma-Add-in-userspace-allocation-API.patch"
SRC_URI += "file://0336-staging-vcsm-cma-Add-cache-control-ioctls.patch"
SRC_URI += "file://0337-staging-vcsm-cma-Alter-dev-node-permissions-to-0666.patch"
SRC_URI += "file://0338-staging-vcsm-cma-Drop-logging-level-on-messages-in-v.patch"
SRC_URI += "file://0339-staging-vcsm-cma-Fixup-the-alloc-code-handling-of-ke.patch"
SRC_URI += "file://0340-Pulled-in-the-multi-frame-buffer-support-from-the-Pi.patch"
SRC_URI += "file://0341-ARM-dts-bcm283x-Move-BCM2835-6-7-specific-to-bcm2835.patch"
SRC_URI += "file://0342-ARM-dts-Add-bcm2711-rpi-4-b.dts-and-components.patch"
SRC_URI += "file://0343-overlays-Add-i2c3-6-and-uart2-5-overlays.patch"
SRC_URI += "file://0344-spi-devicetree-add-overlays-for-spi-3-to-6.patch"
SRC_URI += "file://0345-overlays-Add-the-spi-gpio40-45-overlay.patch"
SRC_URI += "file://0346-config-Permit-LPAE-and-PCIE_BRCMSTB-on-BCM2835.patch"
SRC_URI += "file://0347-configs-Add-bcm2711_defconfig.patch"
SRC_URI += "file://0348-2711-Add-basic-64-bit-support.patch"
SRC_URI += "file://0349-bcm2711_defconfig-add-xhci-platform-support.patch"
SRC_URI += "file://0350-bcm2835-dma-Add-proper-40-bit-DMA-support.patch"
SRC_URI += "file://0351-BCM270X_DT-Leave-bulk-channel-in-dma-channel-mask.patch"
SRC_URI += "file://0352-defconfig-Update-bcm2711-to-match-bcm2709-on-extra-m.patch"
SRC_URI += "file://0353-defconfigs-Add-FB_SIMPLE-to-both-bcmrpi-and-bcm2709-.patch"
SRC_URI += "file://0354-dts-Include-CSI-lane-config-for-csi1.patch"
SRC_URI += "file://0355-bcm2711-dts-Disable-the-v3d-node-by-default.patch"
SRC_URI += "file://0356-clk-bcm2835-Add-support-for-setting-leaf-clock-rates.patch"
SRC_URI += "file://0357-clk-bcm2835-Allow-reparenting-leaf-clocks-while-they.patch"
SRC_URI += "file://0358-HACK-clk-bcm2835-Add-BCM2838_CLOCK_EMMC2-support.patch"
SRC_URI += "file://0359-arm-dts-Fix-Pi4-PWR-LED-configuration.patch"
SRC_URI += "file://0360-usb-add-plumbing-for-updating-interrupt-endpoint-int.patch"
SRC_URI += "file://0361-xhci-implement-xhci_fixup_endpoint-for-interval-adju.patch"
SRC_URI += "file://0362-usbhid-call-usb_fixup_endpoint-after-mangling-interv.patch"
SRC_URI += "file://0363-bcm2838.dtsi-Correct-gic400-memory-address-ranges.patch"
SRC_URI += "file://0364-arm-bcm2835-Add-bcm2838-compatible-string.patch"
SRC_URI += "file://0365-arm-dts-Improve-the-bcm27xx-inclusion-hierarchy.patch"
SRC_URI += "file://0366-arm-dts-First-draft-of-upstream-Pi4-DTS.patch"
SRC_URI += "file://0367-overlays-Fix-compatible-string-for-ds1307-RTC.patch"
SRC_URI += "file://0368-overlays-Fix-further-maxim-ds1307-references.patch"
SRC_URI += "file://0369-overlays-Cosmetic-change-to-upstream-overlay.patch"
SRC_URI += "file://0370-w1-ds2805-rename-w1_family-struct-fixing-c-p-typo.patch"
SRC_URI += "file://0371-w1-ds2413-output_write-cosmetic-fixes-simplify.patch"
SRC_URI += "file://0372-w1-ds2413-add-retry-support-to-state_read.patch"
SRC_URI += "file://0373-w1-ds2413-when-the-slave-is-not-responding-during-re.patch"
SRC_URI += "file://0374-w1-ds2413-fix-state-byte-comparision.patch"
SRC_URI += "file://0375-drm-vc4-Fix-oops-at-boot-with-firmwarekms-on-4.19.patch"
SRC_URI += "file://0376-drm-v3d-Add-support-for-2711.patch"
SRC_URI += "file://0377-drm-v3d-Skip-MMU-flush-if-the-device-is-currently-of.patch"
SRC_URI += "file://0378-drm-v3d-Hook-up-the-runtime-PM-ops.patch"
SRC_URI += "file://0379-drm-v3d-HACK-gut-runtime-pm-for-now.patch"
SRC_URI += "file://0380-drm-v3d-Refactor-job-management.patch"
SRC_URI += "file://0381-drm-v3d-Add-missing-implicit-synchronization.patch"
SRC_URI += "file://0382-drm-vc4-Fix-synchronization-firmwarekms-against-GL-r.patch"
SRC_URI += "file://0383-drm-vc4-Expose-the-format-modifiers-for-firmware-kms.patch"
SRC_URI += "file://0384-drm-vc4-Fix-vblank-timestamping-for-firmwarekms.patch"
SRC_URI += "file://0385-gpu-vc4-fkms-Switch-to-the-newer-mailbox-frame-buffe.patch"
SRC_URI += "file://0386-drm-vc4-Add-an-overlay-plane-to-vc4-firmware-kms.patch"
SRC_URI += "file://0387-drm-vc4-Increase-max-screen-size-to-4096x4096.patch"
SRC_URI += "file://0388-drm-vc4-Add-support-for-multiple-displays-to-fkms.patch"
SRC_URI += "file://0389-drm-vc4-Fix-build-warning.patch"
SRC_URI += "file://0390-drm-vc4-Select-display-to-blank-during-initialisatio.patch"
SRC_URI += "file://0391-drm-vc4-Remove-now-unused-structure.patch"
SRC_URI += "file://0392-drm-vc4-Query-the-display-ID-for-each-display-in-FKM.patch"
SRC_URI += "file://0393-drm-vc4-Set-the-display-number-when-querying-the-dis.patch"
SRC_URI += "file://0394-drm-vc4-Need-to-call-drm_crtc_vblank_-on-off-from-vc.patch"
SRC_URI += "file://0395-drm-vc4-Add-support-for-H-V-flips-on-each-plane-for-.patch"
SRC_URI += "file://0396-drm-vc4-Remove-unused-vc4_fkms_cancel_page_flip-func.patch"
SRC_URI += "file://0397-drm-vc4-Iterate-over-all-planes-in-vc4_crtc_-dis-en-.patch"
SRC_URI += "file://0398-drm-vc4-Bring-fkms-into-line-with-kms-in-blocking-do.patch"
SRC_URI += "file://0399-drm-vc4-Increase-max_width-height-to-7680.patch"
SRC_URI += "file://0400-drm-vc4-FKMS-reads-the-EDID-from-fw-and-supports-mod.patch"
SRC_URI += "file://0401-drm-v3d-Add-support-for-compute-shader-dispatch.patch"
SRC_URI += "file://0402-drm-v3d-Clock-V3D-down-when-not-in-use.patch"
SRC_URI += "file://0403-drm-vc4-firmware-kms-Remove-incorrect-overscan-suppo.patch"
SRC_URI += "file://0404-drm-vc4-Log-flags-in-fkms-mode-set.patch"
SRC_URI += "file://0405-drm-vc4-firmware-kms-Fix-DSI-display-support.patch"
SRC_URI += "file://0406-drm-vc4-Probe-DPI-DSI-timings-from-the-firmware.patch"
SRC_URI += "file://0407-drm-vc4-handle-the-case-where-there-are-no-available.patch"
SRC_URI += "file://0408-drm-vc4-Support-the-VEC-in-FKMS.patch"
SRC_URI += "file://0409-drm-vc4-Fixup-typo-when-setting-HDMI-aspect-ratio.patch"
SRC_URI += "file://0410-drm-vc4-Correct-SAND-support-for-FKMS.patch"
SRC_URI += "file://0411-drm-vc4-fkms-to-query-the-VPU-for-HDMI-clock-limits.patch"
SRC_URI += "file://0412-drm-vc4-Max-resolution-of-7680-is-conditional-on-bei.patch"
SRC_URI += "file://0413-drm-vc4-Fix-T-format-modifiers-in-FKMS.patch"
SRC_URI += "file://0414-drm-vc4-Remove-340MHz-clock-limit-from-FKMS-now-scra.patch"
SRC_URI += "file://0415-drm-vc4-Add-status-of-which-display-is-updated-throu.patch"
SRC_URI += "file://0416-drm-vc4-In-FKMS-look-at-the-modifiers-correctly-for-.patch"
SRC_URI += "file://0417-drm-vc4-Limit-fkms-to-modes-85Hz.patch"
SRC_URI += "file://0418-drm-vc4-Ignore-HVS-unless-initialised.patch"
SRC_URI += "file://0419-drm-vc4_dsi-Fix-DMA-channel-and-memory-leak-in-vc4-3.patch"
SRC_URI += "file://0420-drm-vc4-Add-support-for-color-encoding-on-YUV-planes.patch"
SRC_URI += "file://0421-arm-dts-Add-coherent_pool-1M-to-Pi-4-bootargs.patch"
SRC_URI += "file://0422-configs-Enable-USB_CONFIGFS-m-in-bcmrpi_defconfig.patch"
SRC_URI += "file://0423-configs-And-all-the-other-USB_CONFIGFS-options.patch"
SRC_URI += "file://0424-configs-arm64-bcm2711-Add-MMC_SDHCI_IPROC.patch"
SRC_URI += "file://0425-overlays-Correct-gpio-fan-gpio-flags-for-4.19.patch"
SRC_URI += "file://0426-staging-vcsm-cma-Remove-cache-manipulation-ioctl-fro.patch"
SRC_URI += "file://0427-staging-vcsm-cma-Rework-to-use-dma-APIs-not-CMA.patch"
SRC_URI += "file://0428-staging-vc-sm-cma-Fix-the-few-remaining-coding-style.patch"
SRC_URI += "file://0429-configs-Drop-MMC_SDHCI_BCM2711-from-arm64-bcm2711_de.patch"
SRC_URI += "file://0430-overlays-Add-real-parameters-to-the-rpi-poe-overlay.patch"
SRC_URI += "file://0431-overlays-Rename-pi3-overlays-to-be-less-model-specif.patch"
SRC_URI += "file://0432-i2c-bcm2835-Move-IRQ-request-after-clock-code-in-pro.patch"
SRC_URI += "file://0433-i2c-bcm2835-Ensure-clock-exists-when-probing.patch"
SRC_URI += "file://0434-overlays-i2c-gpio-Fix-the-bus-parameter.patch"
SRC_URI += "file://0435-tty-amba-pl011-Make-TX-optimisation-conditional.patch"
SRC_URI += "file://0436-xhci-add-quirk-for-host-controllers-that-don-t-updat.patch"
SRC_URI += "file://0437-i2c-bcm2835-Set-clock-stretch-timeout-to-35ms.patch"
SRC_URI += "file://0438-overlays-Add-PCF2129-RTC.patch"
SRC_URI += "file://0439-configs-arm64-bcm2711-Use-CONFIG_BRCMSTB_THERMAL-ins.patch"
SRC_URI += "file://0440-overlays-dpi18-and-dpi24-vc4-compatibility.patch"
SRC_URI += "file://0441-overlays-Add-i2c0-and-i2c1-for-regularity.patch"
SRC_URI += "file://0442-Pisound-Remove-spinlock-usage-around-spi_sync.patch"
SRC_URI += "file://0443-arm64-mm-Limit-the-DMA-zone-for-arm64.patch"
SRC_URI += "file://0444-configs-Enable-iio-driver-for-TI-ADS1015.patch"
SRC_URI += "file://0445-bcm2711_defconfig-enable-PCI-portbus-support-and-imp.patch"
SRC_URI += "file://0446-staging-vc04_services-fix-compiling-in-separate-dire.patch"
SRC_URI += "file://0447-usb-host-dwc_otg-fix-compiling-in-separate-directory.patch"
SRC_URI += "file://0448-According-to-5713-pdf-doc-CLOCK_CTRL-is-a-readonly-s.patch"
SRC_URI += "file://0449-drm-vc4-Disable-load-tracking-by-default.patch"
SRC_URI += "file://0450-Revert-drm-vc4-Disable-load-tracking-by-default.patch"
SRC_URI += "file://0451-drm-vc4-Prevent-load-tracking-from-breaking-FKMS.patch"
SRC_URI += "file://0452-ARM-dts-bcm2835-common-Restore-V3D-power-domain.patch"
SRC_URI += "file://0453-net-account-for-the-srctree-rtl8192-cflags.patch"
SRC_URI += "file://0454-staging-bcm2835_camera-Ensure-all-buffers-are-return.patch"
SRC_URI += "file://0455-Ported-pcie-brcmstb-bounce-buffer-implementation-to-.patch"
SRC_URI += "file://0456-drm-vc4-Query-firmware-for-custom-HDMI-mode.patch"
SRC_URI += "file://0457-drm-vc4-Pass-the-drm-vrefresh-to-the-firmware-on-mod.patch"
SRC_URI += "file://0458-overlays-audremap-Support-GPIOs-18-19.patch"
SRC_URI += "file://0459-drm-vc4-Add-support-for-margins-to-fkms.patch"
SRC_URI += "file://0460-drm-vc4-Ensure-zpos-is-always-initialised.patch"
SRC_URI += "file://0461-dts-bcm2838-add-missing-properties-for-pmu-and-gic-n.patch"
SRC_URI += "file://0462-adds-the-Hifiberry-DAC-ADC-PRO-version.patch"
SRC_URI += "file://0463-codecs-Correct-Katana-minimum-volume.patch"
SRC_URI += "file://0464-drm-vc4-A-present-but-empty-dmas-disables-audio.patch"
SRC_URI += "file://0465-overlays-Add-audio-parameter-to-vc4-kms-v3d.patch"
SRC_URI += "file://0466-overlays-Update-the-upstream-overlay.patch"
# This patch has been replaced by an alternative from upstream since at least RCPL 2
#SRC_URI += "file://0467-can-mcp251x-Allow-more-time-after-a-reset.patch"
SRC_URI += "file://0468-Fixup-FKMS-interrupt-handing-for-non-existent-displa.patch"
SRC_URI += "file://0469-drivers-char-Use-correct-name-for-the-Raspberry-Pi-v.patch"
SRC_URI += "file://0470-driver-char-rpivid-also-support-legacy-name.patch"
SRC_URI += "file://0471-hid-usb-Add-device-quirks-for-Freeway-Airmouse-T3-an.patch"
SRC_URI += "file://0472-drm-vc4-Add-Broadcast-RGB-connector-property.patch"
SRC_URI += "file://0473-drm-connector-Add-documentation-for-drm_cmdline_mode.patch"
SRC_URI += "file://0474-drm-modes-Rewrite-the-command-line-parser.patch"
SRC_URI += "file://0475-drm-modes-Support-modes-names-on-the-command-line.patch"
SRC_URI += "file://0476-drm-modes-Allow-to-specify-rotation-and-reflection-o.patch"
SRC_URI += "file://0477-drm-connector-Introduce-a-TV-margins-structure.patch"
SRC_URI += "file://0478-drm-modes-Parse-overscan-properties.patch"
SRC_URI += "file://0479-drm-atomic-Add-a-function-to-reset-connector-TV-prop.patch"
SRC_URI += "file://0480-drm-vc4-hdmi-Set-default-state-margin-at-reset.patch"
SRC_URI += "file://0481-drm-vc4-fkms-Set-default-state-margin-at-reset.patch"
SRC_URI += "file://0482-drm-modes-Don-t-apply-cmdline-s-rotation-if-it-wasn-.patch"
SRC_URI += "file://0483-configs-Add-CONFIG_FRAMEBUFFER_CONSOLE_ROTATION-to-P.patch"
SRC_URI += "file://0484-staging-bcm2835-codec-switch-to-multi-planar-API.patch"
SRC_URI += "file://0485-staging-bcm2835-codec-implement-V4L2_CID_MIN_BUFFERS.patch"
SRC_URI += "file://0486-staging-bcm2835-codec-set-device_caps-in-struct-vide.patch"
SRC_URI += "file://0487-Add-HDMI1-facility-to-the-driver.patch"
SRC_URI += "file://0488-overlays-Add-baudrate-parameter-to-i2c3-i2c6.patch"
SRC_URI += "file://0489-drm-vc4-Resolve-the-vblank-warnings-on-mode-switchin.patch"
SRC_URI += "file://0490-drm-vc4-Remove-unused-mode-variable.patch"
SRC_URI += "file://0491-staging-bcm2835-codec-Expand-logging-on-format-setti.patch"
SRC_URI += "file://0492-staging-bcm2835-codec-Correct-bytesperline-on-format.patch"
SRC_URI += "file://0493-drm-vc4-Add-missing-NULL-check-to-vc4_crtc_consume_e.patch"
SRC_URI += "file://0494-net-bcmgenet-Workaround-2-for-Pi4-Ethernet-fail.patch"
SRC_URI += "file://0495-configs-Regenerate-the-defconfigs.patch"
SRC_URI += "file://0496-configs-Enable-building-the-DS28E17-driver-module.patch"
SRC_URI += "file://0497-ARM-dts-bcm2711-rpi-4-b-I2C-aliases-and-pulls.patch"
SRC_URI += "file://0498-xhci-Use-more-event-ring-segment-table-entries.patch"
SRC_URI += "file://0499-dwc_otg-use-align_buf-for-small-IN-control-transfers.patch"
SRC_URI += "file://0500-configs-arm64-vcm2711-Enable-V3D.patch"
SRC_URI += "file://0501-overlays-sc16ic752-i2c-Fix-xtal-parameter.patch"
SRC_URI += "file://0502-vc-sm-cma-Fix-compatibility-ioctl.patch"
SRC_URI += "file://0503-configs-Add-TINYDRM-modules.patch"
SRC_URI += "file://0504-staging-bcm2835-codec-add-support-for-V4L2_CID_MPEG_.patch"
SRC_URI += "file://0505-staging-bcm2835-codec-remove-unnecessary-padding-on-.patch"
SRC_URI += "file://0506-arm-dts-add-missing-Raspberry-Pi-model-names.patch"
SRC_URI += "file://0507-Add-support-for-the-Audio-Injector-Ultra-in-64-bit-l.patch"
SRC_URI += "file://0508-arch-arm-Add-model-string-to-cpuinfo.patch"
SRC_URI += "file://0509-arch-arm64-Add-Revision-Serial-Model-to-cpuinfo.patch"
SRC_URI += "file://0510-media-dt-bindings-Add-binding-for-the-Sony-IMX219-se.patch"
SRC_URI += "file://0511-media-i2c-Add-driver-for-Sony-IMX219-sensor.patch"
SRC_URI += "file://0512-defconfigs-Add-Sony-IMX219-driver-to-RPi-defconfigs.patch"
SRC_URI += "file://0513-dtoverlays-Add-overlay-for-the-Sony-IMX219-image-sen.patch"
SRC_URI += "file://0514-staging-bcm2835-codec-Fix-non-documentation-comment-.patch"
SRC_URI += "file://0515-staging-bcm2835-codec-Fix-declaration-of-roles.patch"
SRC_URI += "file://0516-staging-bcm2835-codec-Add-role-to-device-name.patch"
SRC_URI += "file://0517-staging-bcm2835-codec-Pass-driver-context-to-create-.patch"
SRC_URI += "file://0518-staging-bcm2835-codec-add-media-controller-support.patch"
SRC_URI += "file://0519-media-bcm2835-unicam-Reduce-scope-of-local-function.patch"
SRC_URI += "file://0520-media-bcm2835-unicam-add-media-controller-support.patch"
SRC_URI += "file://0521-Limit-max_req_size-under-arm64-or-any-other-platform.patch"
SRC_URI += "file://0522-Add-missing-dma_unmap_sg-calls-to-free-relevant-swio.patch"
SRC_URI += "file://0523-overlays-mcp23017-rename-the-GPIO-pins-node-with-the.patch"
SRC_URI += "file://0524-overlays-mcp23017-Add-option-for-not-connecting-the-.patch"
SRC_URI += "file://0525-v4l2-Add-a-Greyworld-AWB-mode.patch"
SRC_URI += "file://0526-staging-bcm2835-camera-Add-greyworld-AWB-mode.patch"
SRC_URI += "file://0527-configs-Add-GPIO_PCA953X-LEDS_PCA9532-PCA955X.patch"
SRC_URI += "file://0528-configs-Set-VIDEO_V4L2_SUBDEV_API-y-on-arm64-bcm2711.patch"
SRC_URI += "file://0529-arm-dts-Give-v3dbus-a-16GB-DMA-address-range.patch"
SRC_URI += "file://0530-drm-vc4-Fix-for-margins-in-composite-SDTV-mode-3223.patch"
SRC_URI += "file://0531-Add-Hifiberry-DAC-DSP-soundcard-driver-3224.patch"
SRC_URI += "file://0532-staging-bcm2835-codec-Allow-height-of-1920.patch"
SRC_URI += "file://0533-staging-bcm2835-codec-Correct-g-s_selection-API-MPLA.patch"
SRC_URI += "file://0534-arm64-dma-mapping-Fix-IOMMU-breakage.patch"
SRC_URI += "file://0535-configs-Regenerate-defconfigs.patch"
SRC_URI += "file://0536-configs-Update-arm64-bcm2711_defconfig-based-on-the-.patch"
SRC_URI += "file://0537-dts-Add-DTS-for-Pi-2B-rev-1.2-with-BCM2837-3235.patch"
SRC_URI += "file://0538-drm-v3d-Fix-merge-error-memory-leak.patch"
SRC_URI += "file://0539-drm-v3d-clean-caches-at-the-end-of-render-jobs-on-re.patch"
SRC_URI += "file://0540-kbuild-Allow-.dtbo-overlays-to-be-built-piecemeal.patch"
SRC_URI += "file://0541-dma-direct-Temporary-DMA-fix-on-arm64.patch"
SRC_URI += "file://0542-configs-Enable-CONFIG_NET_VRF-m.patch"
SRC_URI += "file://0543-configs-Update-bcm2711-arm64-USB-options-to-match-ar.patch"
# This patch is included since at least RCPL 2
#SRC_URI += "file://0544-staging-bcm2835-audio-Fix-draining-behavior-regressi.patch"
SRC_URI += "file://0545-bcm2708_fb-Fix-layout-of-struct-vc4_display_settings.patch"
SRC_URI += "file://0546-ARM-dts-bcm27xx-Fix-DTC-warning-for-memory-node.patch"
SRC_URI += "file://0547-ARM-bcm283x-Enable-DMA-support-for-SPI-controller.patch"
SRC_URI += "file://0548-ARM-dts-bcm2708-rpi-Define-the-downstream-MMC-interf.patch"
SRC_URI += "file://0549-ARM-dts-bcm283x-Define-MMC-interfaces-at-board-level.patch"
SRC_URI += "file://0550-ARM-dts-bcm2835-rpi-zero-w-Fix-bus-width-of-sdhci.patch"
SRC_URI += "file://0551-ARM-dts-bcm2708-rpi-Define-the-downstream-HDMI-power.patch"
SRC_URI += "file://0552-ARM-dts-bcm283x-Enable-HDMI-at-board-level.patch"
SRC_URI += "file://0553-Revert-HACK-clk-bcm2835-Add-BCM2838_CLOCK_EMMC2-supp.patch"
SRC_URI += "file://0554-clk-bcm2835-Introduce-SoC-specific-clock-registratio.patch"
SRC_URI += "file://0555-clk-bcm2835-Add-BCM2711_CLOCK_EMMC2-support.patch"
SRC_URI += "file://0556-ARM-bcm-Switch-board-clk-and-pinctrl-to-bcm2711-comp.patch"
SRC_URI += "file://0557-Revert-pinctrl-bcm2835-Add-support-for-BCM2838.patch"
SRC_URI += "file://0558-pinctrl-bcm2835-Add-support-for-BCM2711-pull-up-func.patch"
SRC_URI += "file://0559-Rename-HDMI-ALSA-device-names-check-for-enable-state.patch"
SRC_URI += "file://0560-pcie-brcmstb-bounce64.c-dev_err-dev_info-for-info-me.patch"
SRC_URI += "file://0561-overlays-gpio-shutdown-Add-debounce-parameter.patch"
SRC_URI += "file://0562-overlays-fix-compatible-for-RPi4.patch"
SRC_URI += "file://0563-media-bcm2835-unicam-Add-support-for-raw14-formats.patch"
SRC_URI += "file://0564-media-bcm2835-unicam-Rework-to-not-cache-the-list-of.patch"
SRC_URI += "file://0565-media-bcm2835-unicam-Support-unpacking-CSI-format-to.patch"
SRC_URI += "file://0566-media-bcm2835-unicam-Add-support-for-luma-greyscale-.patch"
SRC_URI += "file://0567-drm-vc4-Add-support-for-YUV-color-encodings-and-rang.patch"
SRC_URI += "file://0568-drm-vc4-Add-support-for-H-V-flips.patch"
SRC_URI += "file://0569-drm-vc4-Correct-handling-of-rotation-parameter-in-fk.patch"
SRC_URI += "file://0570-configs-Add-CONFIG_WIZNET_W5100-m-and-_SPI-m.patch"
SRC_URI += "file://0571-overlays-Add-w5500-overlay.patch"
SRC_URI += "file://0572-bcm2711-Retain-support-for-old-dtbs.patch"
SRC_URI += "file://0573-media-bcm2835-unicam-Replace-hard-coded-loop-limit-w.patch"
SRC_URI += "file://0574-media-bcm2835-unicam-Fix-one-to-many-mapping-for-YUY.patch"
SRC_URI += "file://0575-dt-bindings-Add-binding-for-the-Infineon-IRS1125-sen.patch"
SRC_URI += "file://0576-media-i2c-Add-a-driver-for-the-Infineon-IRS1125-dept.patch"
SRC_URI += "file://0577-configs-Add-CONFIG_VIDEO_IRS1125-to-the-defconfigs.patch"
SRC_URI += "file://0578-dtoverlays-Add-an-overlay-for-the-Infineon-IRS1125.patch"
SRC_URI += "file://0579-rpi-wm8804-soundcard-Fixed-MCLKDIV-for-Allo-Digione.patch"
SRC_URI += "file://0580-dts-bcm2838-Disable-DWC-OTG-block-by-default.patch"
# Not needed since RCPL 3
#SRC_URI += "file://0581-ALSA-usb-audio-Add-DSD-support-for-Gustard-U16-X26-U.patch"
SRC_URI += "file://0582-staging-bcm2835-codec-Add-support-for-ENUM_FRAMESIZE.patch"
SRC_URI += "file://0583-staging-bcm2835-codec-Correct-buffer-type-check-on-G.patch"
SRC_URI += "file://0584-staging-bcm2835-codec-Set-default-and-error-check-ti.patch"
SRC_URI += "file://0585-staging-bcm2835-codec-Fix-imbalance-in-dma_buf_get-d.patch"
SRC_URI += "file://0586-drm-vc4-Added-calls-for-firmware-display-blank-unbla.patch"
SRC_URI += "file://0587-configs-Add-CGROUP_BPF-and-BPF_SYSCALL.patch"

# Additional patches
SRC_URI += "file://0001-Fix-compile-error-caused-by-incorrect-include-path.patch"
